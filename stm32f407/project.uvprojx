# Keil uVision project project.uvprojx, settings and files
target laser_controller_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx USE_FULL_LL_DRIVER
  c include: .\applications;.;..\libraries\HAL_Drivers;.\board\CubeMX_Config\Inc;..\rt-thread\include;..\rt-thread\libcpu\arm\cortex-m4;..\rt-thread\libcpu\arm\common;..\rt-thread\components\drivers\include;..\rt-thread\components\finsh;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;..\rt-thread\components\drivers\include\drivers;.\applications\task_communication;.\applications\task_motor_control;.\applications\task_pwm_output;.\board;.\board\CubeMX_Config;.\board\ports;..\libraries\HAL_Drivers\config;..\rt-thead_third_package\fal\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group task_idle
    applications/: main.c
  group task_communication
    ./applications/task_communication/: app_task_communication.c
  group task_motor_control
    ./applications/task_motor_control/: app_task_motor_control.c
  group task_pwm_output
    ./applications/task_pwm_output/: app_task_pwm_output.c drv_pwm_dma_output.c
  group rt-thread/kernel
    ../rt-thread/src/: components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c clock.c
  group rt-thread/finsh
    ../rt-thread/components/finsh/: symbol.c cmd.c msh.c msh_file.c shell.c
  group rt-thread/libcpu/cortex-m4
    ../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group rt-thread/componnent/deviceDrivers/usb_device/core
    ../rt-thread/components/drivers/usb/usbdevice/core/: usbdevice.c core.c
  group rt-thread/componnent/deviceDrivers/usb_device/class
    ../rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group rt-thread/component/deviceDrivers
    ../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/serial/: serial.c
  group rt-thread/third_package/fal
    ../rt-thead_third_package/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group chip_midlelayer_drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_usbd_fs.c drv_pwm.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group stm32_library
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
